<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Final_Proyect_GatewayIOT.ewp</path>
  </project>
  <batchBuild />
</workspace>
